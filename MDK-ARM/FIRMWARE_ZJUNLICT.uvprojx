# Keil uVision project FIRMWARE_ZJUNLICT.uvprojx, settings and files
target FIRMWARE_ZJUNLICT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: FIRMWARE_ZJUNLICT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,__FPU_PRESENT=1,__TARGET_FPU_VFP,CC_ARM
  c include: ../Inc;                                                                        ../Drivers/STM32H7xx_HAL_Driver/Inc;                                                                        ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                                                                        ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                                                                        ../Drivers/CMSIS/Include;                                                                        ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: NRF24L01.c dma_mine.c main.c gpio.c adc.c dma.c hrtim.c i2c.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
software components: CMSIS:CORE 5.2.0
